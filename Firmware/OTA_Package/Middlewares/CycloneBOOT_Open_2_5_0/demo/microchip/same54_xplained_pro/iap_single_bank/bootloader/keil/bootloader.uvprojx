# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (ARM-ADS)
  device: ATSAME54P20A Atmel
  pack: Microchip.SAME54_DFP.3.7.122
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: python.exe ..\scripts\misc\copy_file.py .\bootloader.bin ..\
  c flags: Optim=1 OneElfS=1
  c define: __SAME54P20A__ USE_CMSIS_INIT USE_SAME54_XPLAINED_PRO
  c include: ..\src;..\..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\..\third_party\microchip\devices\same54;..\..\..\..\..\..\third_party\microchip\boards\same54_xplained_pro;..\..\..\..\..\..\common;..\..\..\..\..\..\cyclone_crypto;..\..\..\..\..\..\cyclone_boot
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\same54_flash.sct
  group Demo Sources
    ./: startup_same54.s retarget.c
    ../src/: system_same54.c main.c debug.c
  group Demo Headers
    ../src/: os_port_config.h boot_config.h crypto_config.h
  group Common Sources
    ../../../../../../common/: cpu_endian.c os_port_none.c date_time.c str.c
  group Common Headers
    ../../../../../../common/: cpu_endian.h os_port.h os_port_none.h date_time.h str.h error.h debug.h
  group CycloneBOOT Sources
    ../../../../../../cyclone_boot/core/: crc32.c
    ../../../../../../cyclone_boot/drivers/mcu/arm/: sam_ed_5x_mcu_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: sam_ed_5x_flash_driver.c
    ../../../../../../cyclone_boot/image/: image.c
    ../../../../../../cyclone_boot/memory/: memory.c
    ../../../../../../cyclone_boot/security/: cipher.c
    ../../../../../../cyclone_boot/bootloader/: boot.c boot_fallback.c boot_common.c
  group CycloneBOOT Headers
    ../../../../../../cyclone_boot/core/: cboot_error.h crc32.h flash.h mcu.h
    ../../../../../../cyclone_boot/drivers/mcu/arm/: sam_ed_5x_mcu_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: sam_ed_5x_flash_driver.h
    ../../../../../../cyclone_boot/image/: image.h
    ../../../../../../cyclone_boot/memory/: memory.h memory_ex.h
    ../../../../../../cyclone_boot/security/: cipher.h
    ../../../../../../cyclone_boot/bootloader/: boot.h boot_fallback.h boot_common.h
  group CycloneCRYPTO Sources
    ../../../../../../cyclone_crypto/hash/: sha256.c
    ../../../../../../cyclone_crypto/cipher/: aes.c
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.c
  group CycloneCRYPTO Headers
    ../../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../../cyclone_crypto/cipher/: aes.h
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.h
  group SAME54-Xplained-Pro Headers
    ../../../../../../third_party/microchip/boards/same54_xplained_pro/: same54_xplained_pro.h
