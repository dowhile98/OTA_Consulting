# Keil uVision project iap_demo.uvprojx, settings and files
target iap_demo (ARM-ADS)
  device: ATSAME54P20A Atmel
  pack: Microchip.SAME54_DFP.3.7.122
  cpu: IRAM(0x20000000,0x40000) IRAM2(0x20000000,0x8000) IRAM3(0x20000000,0x8000) IRAM4(0x47000000,0x2000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iap_demo
  BeforeMake: ..\..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: python.exe ..\scripts\misc\copy_file.py .\iap_demo.bin ..\
  c flags: Optim=1 OneElfS=1
  c define: __SAME54P20A__ USE_CMSIS_INIT USE_SAME54_XPLAINED_PRO FLASH_DB_MODE
  c include: ..\src;..\..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\..\third_party\microchip\devices\same54;..\..\..\..\..\..\third_party\microchip\boards\same54_xplained_pro;..\..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\..\common;..\..\..\..\..\..\cyclone_tcp;..\..\..\..\..\..\cyclone_crypto;..\..\..\..\..\..\cyclone_boot
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\same54_flash.sct
  group Demo Sources
    ./: startup_same54.s retarget.c
    ../src/: system_same54.c main.c debug.c http_server_callbacks.c res.c
  group Demo Headers
    ../src/: os_port_config.h FreeRTOSConfig.h boot_config.h net_config.h crypto_config.h http_server_callbacks.h version.h
  group Common Sources
    ../../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneBOOT Sources
    ../../../../../../cyclone_boot/core/: crc32.c
    ../../../../../../cyclone_boot/drivers/mcu/arm/: sam_ed_5x_mcu_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: sam_ed_5x_flash_driver.c
    ../../../../../../cyclone_boot/image/: image.c image_process.c image_utils.c
    ../../../../../../cyclone_boot/memory/: memory.c memory_ex.c
    ../../../../../../cyclone_boot/security/: verify.c verify_auth.c verify_sign.c cipher.c
    ../../../../../../cyclone_boot/update/: update.c update_misc.c update_fallback.c
  group CycloneBOOT Headers
    ../../../../../../cyclone_boot/core/: cboot_error.h crc32.h flash.h mcu.h
    ../../../../../../cyclone_boot/drivers/mcu/arm/: sam_ed_5x_mcu_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: sam_ed_5x_flash_driver.h
    ../../../../../../cyclone_boot/image/: image.h image_process.h image_utils.h
    ../../../../../../cyclone_boot/memory/: memory.h memory_ex.h
    ../../../../../../cyclone_boot/security/: verify.h verify_auth.h verify_sign.h cipher.h
    ../../../../../../cyclone_boot/update/: update.h update_misc.h update_fallback.h
  group CycloneTCP Sources
    ../../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../../cyclone_tcp/drivers/mac/: same54_eth_driver.c
    ../../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.c
    ../../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_multicast.c ipv4_frag.c ipv4_misc.c icmp.c
    ../../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c ipv6_multicast.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../../cyclone_tcp/drivers/mac/: same54_eth_driver.h
    ../../../../../../cyclone_tcp/drivers/phy/: ksz8091_driver.h
    ../../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_multicast.h ipv4_frag.h ipv4_misc.h icmp.h
    ../../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h ipv6_multicast.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group CycloneCRYPTO Sources
    ../../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c rsa_misc.c
    ../../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c ec_misc.c
    ../../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../../cyclone_crypto/pkix/: pem_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_validate.c x509_cert_ext_parse.c x509_common.c x509_sign_parse.c x509_sign_verify.c
    ../../../../../../cyclone_crypto/kdf/: hkdf.c
    ../../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h rsa_misc.h
    ../../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h ec_misc.h
    ../../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../../cyclone_crypto/pkix/: pem_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_cert_parse.h x509_cert_validate.h x509_cert_ext_parse.h x509_common.h x509_sign_parse.h x509_sign_verify.h
    ../../../../../../cyclone_crypto/kdf/: hkdf.h
    ../../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group SAME54-Xplained-Pro Headers
    ../../../../../../third_party/microchip/boards/same54_xplained_pro/: same54_xplained_pro.h
