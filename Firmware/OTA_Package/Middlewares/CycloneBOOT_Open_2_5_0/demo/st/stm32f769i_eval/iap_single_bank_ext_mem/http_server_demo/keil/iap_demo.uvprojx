# Keil uVision project iap_demo.uvprojx, settings and files
target iap_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F769NIHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.1
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: iap_demo
  BeforeMake: ..\..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: python.exe ..\scripts\misc\copy_file.py .\iap_demo.bin ..\
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F769xx USE_HAL_DRIVER USE_STM32F769I_EVAL USE_IOEXPANDER
  c include: ..\src;..\..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\..\third_party\st\devices\stm32f7xx;..\..\..\..\..\..\third_party\st\drivers\stm32f7xx_hal_driver\inc;..\..\..\..\..\..\third_party\st\boards\stm32f769i_eval;..\..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\..\common;..\..\..\..\..\..\cyclone_tcp;..\..\..\..\..\..\cyclone_crypto;..\..\..\..\..\..\cyclone_boot
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\stm32f769_flash.sct
  group Demo Sources
    ./: startup_stm32f769xx.s retarget.c
    ../src/: system_stm32f7xx.c stm32f7xx_it.c main.c debug.c smi_driver.c http_server_callbacks.c res.c
  group Demo Headers
    ../src/: os_port_config.h FreeRTOSConfig.h stm32f7xx_hal_conf.h stm32f7xx_it.h boot_config.h net_config.h crypto_config.h smi_driver.h http_server_callbacks.h version.h
  group CycloneBOOT Sources
    ../../../../../../cyclone_boot/core/: crc32.c
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32f7xx_mcu_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32f7xx_flash_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/external/: n25q512a_flash_driver.c
    ../../../../../../cyclone_boot/image/: image.c image_process.c image_utils.c
    ../../../../../../cyclone_boot/memory/: memory.c memory_ex.c
    ../../../../../../cyclone_boot/security/: verify.c verify_auth.c verify_sign.c cipher.c
    ../../../../../../cyclone_boot/update/: update.c update_misc.c update_fallback.c
  group CycloneBOOT Headers
    ../../../../../../cyclone_boot/core/: cboot_error.h crc32.h flash.h mcu.h
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32f7xx_mcu_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32f7xx_flash_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/external/: n25q512a_flash_driver.h
    ../../../../../../cyclone_boot/image/: image.h image_process.h image_utils.h
    ../../../../../../cyclone_boot/memory/: memory.h memory_ex.h
    ../../../../../../cyclone_boot/security/: verify.h verify_auth.h verify_sign.h cipher.h
    ../../../../../../cyclone_boot/update/: update.h update_misc.h update_fallback.h
  group Common Sources
    ../../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../../cyclone_tcp/drivers/mac/: stm32f7xx_eth_driver.c
    ../../../../../../cyclone_tcp/drivers/phy/: dp83848_driver.c
    ../../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_multicast.c ipv4_frag.c ipv4_misc.c icmp.c
    ../../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c igmp_debug.c
    ../../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c ipv6_multicast.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../../cyclone_tcp/mld/: mld_node.c mld_node_misc.c mld_common.c mld_debug.c
    ../../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
  group CycloneTCP Headers
    ../../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../../cyclone_tcp/drivers/mac/: stm32f7xx_eth_driver.h
    ../../../../../../cyclone_tcp/drivers/phy/: dp83848_driver.h
    ../../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_multicast.h ipv4_frag.h ipv4_misc.h icmp.h
    ../../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h igmp_debug.h
    ../../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h ipv6_multicast.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../../cyclone_tcp/mld/: mld_node.h mld_node_misc.h mld_common.h mld_debug.h
    ../../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
  group CycloneCRYPTO Sources
    ../../../../../../cyclone_crypto/hardware/stm32f7xx/: stm32f7xx_crypto.c stm32f7xx_crypto_trng.c
    ../../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../../cyclone_crypto/pkc/: dh.c rsa.c rsa_misc.c dsa.c
    ../../../../../../cyclone_crypto/ecc/: ec.c ec_misc.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c
    ../../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../../cyclone_crypto/pkix/: pem_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_validate.c x509_cert_ext_parse.c x509_common.c x509_sign_parse.c x509_sign_verify.c
    ../../../../../../cyclone_crypto/kdf/: hkdf.c
    ../../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../../cyclone_crypto/hardware/stm32f7xx/: stm32f7xx_crypto.h stm32f7xx_crypto_trng.h
    ../../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../../cyclone_crypto/pkc/: dh.h rsa.h rsa_misc.h dsa.h
    ../../../../../../cyclone_crypto/ecc/: ec.h ec_misc.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h
    ../../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../../cyclone_crypto/pkix/: pem_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_cert_parse.h x509_cert_validate.h x509_cert_ext_parse.h x509_common.h x509_sign_parse.h x509_sign_verify.h
    ../../../../../../cyclone_crypto/kdf/: hkdf.h
    ../../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group STM32F769I-EVAL Sources
    ../../../../../../third_party/st/boards/stm32f769i_eval/: stm32f769i_eval.c stm32f769i_eval_camera.c stm32f769i_eval_eeprom.c stm32f769i_eval_io.c stm32f769i_eval_lcd.c stm32f769i_eval_nor.c stm32f769i_eval_qspi.c stm32f769i_eval_sd.c stm32f769i_eval_sdram.c stm32f769i_eval_sram.c stm32f769i_eval_ts.c
    ../../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.c
    ../../../../../../third_party/st/boards/components/ft6x06/: ft6x06.c
    ../../../../../../third_party/st/boards/components/s5k5cag/: s5k5cag.c
    ../../../../../../third_party/st/boards/components/otm8009a/: otm8009a.c
    ../../../../../../third_party/st/boards/components/ov5640/: ov5640.c
  group STM32F769I-EVAL Headers
    ../../../../../../third_party/st/boards/stm32f769i_eval/: stm32f769i_eval.h stm32f769i_eval_camera.h stm32f769i_eval_eeprom.h stm32f769i_eval_io.h stm32f769i_eval_lcd.h stm32f769i_eval_nor.h stm32f769i_eval_qspi.h stm32f769i_eval_sd.h stm32f769i_eval_sdram.h stm32f769i_eval_sram.h stm32f769i_eval_ts.h
    ../../../../../../third_party/st/boards/components/mfxstm32l152/: mfxstm32l152.h
    ../../../../../../third_party/st/boards/components/ft6x06/: ft6x06.h
    ../../../../../../third_party/st/boards/components/s5k5cag/: s5k5cag.h
    ../../../../../../third_party/st/boards/components/otm8009a/: otm8009a.h
    ../../../../../../third_party/st/boards/components/ov5640/: ov5640.h
  group STM32F7xx HAL Drivers Sources
    ../../../../../../third_party/st/drivers/stm32f7xx_hal_driver/src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group STM32F7xx HAL Drivers Headers
    ../../../../../../third_party/st/drivers/stm32f7xx_hal_driver/inc/: stm32f7xx_hal.h stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.h stm32f7xx_hal_cec.h stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.h stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dma2d.h stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.h stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.h stm32f7xx_hal_nand.h stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.h stm32f7xx_hal_sram.h stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.h
