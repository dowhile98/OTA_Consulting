# Keil uVision project iap_demo.uvprojx, settings and files
target iap_demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7A3ZITxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: iap_demo
  BeforeMake: ..\..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: python.exe ..\scripts\misc\copy_file.py .\iap_demo.bin ..\
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32H7A3xxQ USE_HAL_DRIVER USE_NUCLEO_H7A3ZI_Q STM32H7A3xI FLASH_DB_MODE __USE_C99_MATH
  c include: ..\src;..\..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\..\third_party\st\devices\stm32h7xx;..\..\..\..\..\..\third_party\st\drivers\stm32h7xx_hal_driver\inc;..\..\..\..\..\..\third_party\st\boards\stm32h7xx_nucleo;..\..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm7\r0p1;..\..\..\..\..\..\common;..\..\..\..\..\..\cyclone_crypto;..\..\..\..\..\..\cyclone_boot
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: .\stm32h7a3_flash.sct
  group Demo Sources
    ./: startup_stm32h7a3xxq.s retarget.c
    ../src/: system_stm32h7xx.c stm32h7xx_it.c main.c debug.c res.c uart_user.c common.c ymodem.c
  group Demo Headers
    ../src/: os_port_config.h FreeRTOSConfig.h stm32h7xx_hal_conf.h stm32h7xx_nucleo_conf.h stm32h7xx_it.h uart_user.h boot_config.h crypto_config.h uart_user.h common.h ymodem.h version.h
  group Common Sources
    ../../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneBOOT Sources
    ../../../../../../cyclone_boot/core/: crc32.c
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32h7xx_mcu_driver.c
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32h7xx_flash_driver.c
    ../../../../../../cyclone_boot/image/: image.c image_process.c image_utils.c
    ../../../../../../cyclone_boot/memory/: memory.c memory_ex.c
    ../../../../../../cyclone_boot/security/: verify.c verify_auth.c verify_sign.c cipher.c
    ../../../../../../cyclone_boot/update/: update.c update_misc.c update_fallback.c
  group CycloneBOOT Headers
    ../../../../../../cyclone_boot/core/: cboot_error.h crc32.h flash.h mcu.h
    ../../../../../../cyclone_boot/drivers/mcu/arm/: stm32h7xx_mcu_driver.h
    ../../../../../../cyclone_boot/drivers/memory/flash/internal/: stm32h7xx_flash_driver.h
    ../../../../../../cyclone_boot/image/: image.h image_process.h image_utils.h
    ../../../../../../cyclone_boot/memory/: memory.h memory_ex.h
    ../../../../../../cyclone_boot/security/: verify.h verify_auth.h verify_sign.h cipher.h
    ../../../../../../cyclone_boot/update/: update.h update_misc.h update_fallback.h
  group CycloneCRYPTO Sources
    ../../../../../../cyclone_crypto/hardware/stm32h7xx/: stm32h7xx_crypto.c stm32h7xx_crypto_trng.c
    ../../../../../../cyclone_crypto/hash/: md5.c sha1.c sha224.c sha256.c sha384.c sha512.c
    ../../../../../../cyclone_crypto/mac/: hmac.c poly1305.c
    ../../../../../../cyclone_crypto/cipher/: rc4.c idea.c des.c des3.c aes.c camellia.c seed.c aria.c chacha.c
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.c
    ../../../../../../cyclone_crypto/aead/: ccm.c gcm.c chacha20_poly1305.c
    ../../../../../../cyclone_crypto/pkc/: dh.c rsa.c dsa.c rsa_misc.c
    ../../../../../../cyclone_crypto/ecc/: ec.c ec_curves.c ecdh.c ecdsa.c eddsa.c curve25519.c curve448.c x25519.c x448.c ed25519.c ed448.c ec_misc.c
    ../../../../../../cyclone_crypto/mpi/: mpi.c
    ../../../../../../cyclone_crypto/encoding/: base64.c asn1.c oid.c
    ../../../../../../cyclone_crypto/pkix/: pem_import.c pem_decrypt.c pem_common.c pkcs5_decrypt.c pkcs5_common.c pkcs8_key_parse.c x509_key_parse.c x509_cert_parse.c x509_cert_validate.c x509_cert_ext_parse.c x509_common.c x509_sign_parse.c x509_sign_verify.c
    ../../../../../../cyclone_crypto/kdf/: hkdf.c
    ../../../../../../cyclone_crypto/rng/: yarrow.c
  group CycloneCRYPTO Headers
    ../../../../../../cyclone_crypto/core/: crypto.h
    ../../../../../../cyclone_crypto/hardware/stm32h7xx/: stm32h7xx_crypto.h stm32h7xx_crypto_trng.h
    ../../../../../../cyclone_crypto/hash/: md5.h sha1.h sha224.h sha256.h sha384.h sha512.h
    ../../../../../../cyclone_crypto/mac/: hmac.h poly1305.h
    ../../../../../../cyclone_crypto/cipher/: rc4.h idea.h des.h des3.h aes.h camellia.h seed.h aria.h chacha.h
    ../../../../../../cyclone_crypto/cipher_modes/: cbc.h
    ../../../../../../cyclone_crypto/aead/: ccm.h gcm.h chacha20_poly1305.h
    ../../../../../../cyclone_crypto/pkc/: dh.h rsa.h dsa.h rsa_misc.h
    ../../../../../../cyclone_crypto/ecc/: ec.h ec_curves.h ecdh.h ecdsa.h eddsa.h curve25519.h curve448.h x25519.h x448.h ed25519.h ed448.h ec_misc.h
    ../../../../../../cyclone_crypto/mpi/: mpi.h
    ../../../../../../cyclone_crypto/encoding/: base64.h asn1.h oid.h
    ../../../../../../cyclone_crypto/pkix/: pem_import.h pem_decrypt.h pem_common.h pkcs5_decrypt.h pkcs5_common.h pkcs8_key_parse.h x509_key_parse.h x509_cert_parse.h x509_cert_validate.h x509_cert_ext_parse.h x509_common.h x509_sign_parse.h x509_sign_verify.h
    ../../../../../../cyclone_crypto/kdf/: hkdf.h
    ../../../../../../cyclone_crypto/rng/: yarrow.h
  group FreeRTOS Sources
    ../../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: port.c
    ../../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../../third_party/freertos/portable/rvds/arm_cm7/r0p1/: portmacro.h
    ../../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group Nucleo-H7A3ZI-Q Sources
    ../../../../../../third_party/st/boards/stm32h7xx_nucleo/: stm32h7xx_nucleo.c
  group Nucleo-H7A3ZI-Q Headers
    ../../../../../../third_party/st/boards/stm32h7xx_nucleo/: stm32h7xx_nucleo.h stm32h7xx_nucleo_errno.h
  group STM32H7xx HAL Drivers Sources
    ../../../../../../third_party/st/drivers/stm32h7xx_hal_driver/src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c
  group STM32H7xx HAL Drivers Headers
    ../../../../../../third_party/st/drivers/stm32h7xx_hal_driver/inc/: stm32h7xx_hal.h stm32h7xx_hal_adc.h stm32h7xx_hal_adc_ex.h stm32h7xx_hal_cec.h stm32h7xx_hal_comp.h stm32h7xx_hal_cortex.h stm32h7xx_hal_crc.h stm32h7xx_hal_crc_ex.h stm32h7xx_hal_cryp.h stm32h7xx_hal_cryp_ex.h stm32h7xx_hal_dac.h stm32h7xx_hal_dac_ex.h stm32h7xx_hal_dcmi.h stm32h7xx_hal_def.h stm32h7xx_hal_dfsdm.h stm32h7xx_hal_dma.h stm32h7xx_hal_dma_ex.h stm32h7xx_hal_dma2d.h stm32h7xx_hal_dsi.h stm32h7xx_hal_exti.h stm32h7xx_hal_fdcan.h stm32h7xx_hal_flash.h stm32h7xx_hal_flash_ex.h stm32h7xx_hal_gpio.h stm32h7xx_hal_gpio_ex.h stm32h7xx_hal_hash.h stm32h7xx_hal_hash_ex.h stm32h7xx_hal_hcd.h stm32h7xx_hal_hrtim.h stm32h7xx_hal_hsem.h stm32h7xx_hal_i2c.h stm32h7xx_hal_i2c_ex.h stm32h7xx_hal_i2s.h stm32h7xx_hal_i2s_ex.h stm32h7xx_hal_irda.h stm32h7xx_hal_irda_ex.h stm32h7xx_hal_iwdg.h stm32h7xx_hal_jpeg.h stm32h7xx_hal_lptim.h stm32h7xx_hal_ltdc.h stm32h7xx_hal_ltdc_ex.h stm32h7xx_hal_mdios.h stm32h7xx_hal_mdma.h stm32h7xx_hal_mmc.h stm32h7xx_hal_mmc_ex.h stm32h7xx_hal_nand.h stm32h7xx_hal_nor.h stm32h7xx_hal_opamp.h stm32h7xx_hal_opamp_ex.h stm32h7xx_hal_pcd.h stm32h7xx_hal_pcd_ex.h stm32h7xx_hal_pwr.h stm32h7xx_hal_pwr_ex.h stm32h7xx_hal_qspi.h stm32h7xx_hal_ramecc.h stm32h7xx_hal_rcc.h stm32h7xx_hal_rcc_ex.h stm32h7xx_hal_rng.h stm32h7xx_hal_rtc.h stm32h7xx_hal_rtc_ex.h stm32h7xx_hal_sai.h stm32h7xx_hal_sai_ex.h stm32h7xx_hal_sd.h stm32h7xx_hal_sdram.h stm32h7xx_hal_sd_ex.h stm32h7xx_hal_smartcard.h stm32h7xx_hal_smartcard_ex.h stm32h7xx_hal_smbus.h stm32h7xx_hal_spdifrx.h stm32h7xx_hal_spi.h stm32h7xx_hal_spi_ex.h stm32h7xx_hal_sram.h stm32h7xx_hal_swpmi.h stm32h7xx_hal_tim.h stm32h7xx_hal_tim_ex.h stm32h7xx_hal_uart.h stm32h7xx_hal_uart_ex.h stm32h7xx_hal_usart.h stm32h7xx_hal_usart_ex.h stm32h7xx_hal_wwdg.h stm32h7xx_ll_adc.h stm32h7xx_ll_bdma.h stm32h7xx_ll_bus.h stm32h7xx_ll_comp.h stm32h7xx_ll_cortex.h stm32h7xx_ll_crc.h stm32h7xx_ll_dac.h stm32h7xx_ll_delayblock.h stm32h7xx_ll_dma.h stm32h7xx_ll_dma2d.h stm32h7xx_ll_dmamux.h stm32h7xx_ll_exti.h stm32h7xx_ll_fmc.h stm32h7xx_ll_gpio.h stm32h7xx_ll_hrtim.h stm32h7xx_ll_hsem.h stm32h7xx_ll_i2c.h stm32h7xx_ll_iwdg.h stm32h7xx_ll_lptim.h stm32h7xx_ll_lpuart.h stm32h7xx_ll_mdma.h stm32h7xx_ll_opamp.h stm32h7xx_ll_pwr.h stm32h7xx_ll_rcc.h stm32h7xx_ll_rng.h stm32h7xx_ll_rtc.h stm32h7xx_ll_sdmmc.h stm32h7xx_ll_spi.h stm32h7xx_ll_swpmi.h stm32h7xx_ll_system.h stm32h7xx_ll_tim.h stm32h7xx_ll_usart.h stm32h7xx_ll_usb.h stm32h7xx_ll_wwdg.h
